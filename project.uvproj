# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group main
    ./: STARTUP.A51 main.c readme.txt
  group hardware
    ./src/: MFRC522.C RC_control.C
